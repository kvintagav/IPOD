# Keil uVision project clock_ipod.uvprojx, settings and files
target STM32L152 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: clock_ipod
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152
  c include: .\inc;.\STM32L1xx_StdPeriph_Driver\inc;.\DEVICE\STM32L152
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./src/: main.c lcd-hd44780.c ipod.c misc.c init_file.c
    ./DEVICE/STM32F100/: stm32f10x_it.c
    ./DEVICE/STM32F400/: stm32f4xx_it.c
    ./DEVICE/STM32L152/: stm32l1xx_it.c
  group STM32L1xx_StdPeriph_Driver
    ./STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ::Device
    RTE/Device/STM32L152RB/: startup_stm32l1xx_md.s system_stm32l1xx.c
    RTE/Device/STM32F103RB/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40xx.s system_stm32f4xx.c
target STM32F100 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: clock_ipod
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM32F10B
  c include: .\inc;.\STM32F10x_StdPeriph_Driver\inc;.\DEVICE\STM32F100
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F400 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: clock_ipod
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, USE_STM32F4XX
  c include: .\inc;.\DEVICE\STM32F400;.\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0
